SUMMARY = "Sample application for testing"
DESCRIPTION = "A sample BitBake recipe used for unit testing yocto-sbom"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=abc123"
SRCREV = "a1b2c3d4e5f6a1b2c3d4e5f6a1b2c3d4e5f6a1b2"
SRCBRANCH = "main"
SRC_URI = "git://github.com/example/sample.git;branch=${SRCBRANCH};protocol=https"
PV = "1.2.3"
DEPENDS = "boost openssl"
RDEPENDS_${PN} = "libsample-utils python3-flask"
